# Keil uVision project GeoSol.uvproj, settings and files
target mbed FRDM-K64F (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: GeoSol
  AfterMake: fromelf --bin -o build\GeoSol_K64F.bin build\GeoSol.axf
  c flags: Optim=1
  c define: TARGET_RTOS_M4_M7,  TARGET_FF_ARDUINO,  __CORTEX_M4,  TARGET_KPSDK_MCUS,  TARGET_KPSDK_CODE,  TARGET_FRDM,  TARGET_CORTEX_M,  CPU_MK64FN1M0VMD12,  __FPU_PRESENT=1,  TARGET_Freescale,  TARGET_M4,  __MBED__=1,  ARM_MATH_CM4,  TARGET_K64F,  TARGET_LIKE_CORTEX_M4,  MBED_BUILD_TIMESTAMP=1459857808.53,  FSL_RTOS_MBED,  TOOLCHAIN_ARM,  TARGET_MCU_K64F,  TOOLCHAIN_ARM_STD,  TARGET_LIKE_MBED,  __ASSERT_MSG,
  c misc: --gnu --no_rtti  --pch --pch_dir=build
  c include: .;  C12832;  TinyGPS;  mbed-rtos;  mbed-rtos/rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_CORTEX_M;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM;  mbed;  mbed/TARGET_K64F;  mbed/TARGET_K64F/TARGET_Freescale;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_K64F;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_K64F/TARGET_FRDM;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_K64F/device;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_K64F/device/MK64F12;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/src;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog;  mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities;  mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x40000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64F.sct
  link misc: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/startup_MK64F12.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/system_MK64F12.o
            
              mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
    mbed-rtos/rtx/TARGET_CORTEX_M/: HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
    ./: main.cpp
    C12832/: GraphicsDisplay.cpp C12832.cpp TextDisplay.cpp
    TinyGPS/: TinyGPS.cpp
    mbed-rtos/rtos/: Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
